# IAR project RTOSDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_USB_OTG_FS
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: STM32\; STM32\board\; STM32\Libraries\STM32F4xx_StdPeriph_Driver\inc\; STM32\Libraries\CMSIS\ST\STM32F4xx\Include\; STM32\Libraries\CMSIS\Include\; STM32\Libraries\STM32F4xx_StdPeriph_Driver\inc\; STM32\Libraries\STM32_USB_OTG_Driver\inc\; STM32\Libraries\STM32_USB_Device_Library\Class\hid\inc\; STM32\Libraries\STM32_USB_Device_Library\Core\inc\; uCos-II\Source\; uCos-II\Ports\; USER_CODE\; uCos-II\Config\; uCos-II\uC-LIB\; uCos-II\uC-CPU\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: STM32\; STM32\board\; STM32\Libraries\STM32F4xx_StdPeriph_Driver\inc\; STM32\Libraries\CMSIS\ST\STM32F4xx\Include\; STM32\Libraries\CMSIS\Include\; STM32\Libraries\STM32F4xx_StdPeriph_Driver\inc\; STM32\Libraries\STM32_USB_OTG_Driver\inc\; STM32\Libraries\STM32_USB_Device_Library\Class\hid\inc\; STM32\Libraries\STM32_USB_Device_Library\Core\inc\; uCos-II\Source\; uCos-II\Ports\; USER_CODE\; uCos-II\uC-LIB\; uCos-II\uC-CPU\; uCos-II\Config\
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    STM32/: stm32f4xx_it.c
  group BSP
    STM32/: bsp.c bsp_int.c bsp_periph.c
  group BSP/ST_and_IAR_code/board
    STM32/board/: stm32f4_discovery.c
  group BSP/ST_and_IAR_code/startup
    STM32/startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group BSP/ST_and_IAR_code/STM32F4xx_StdPeriph_Driver
    STM32/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uCOS-II/uCOS-II_CPU
    uCOS-II/uC-CPU/: cpu_a.asm
  group uCOS-II/uCOS-II_Lib
    uCOS-II/uC-LIB/: lib_ascii.c lib_mem.c lib_mem_a.asm lib_str.c
  group uCOS-II/uCOS-II_Source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/uCOS_II_Ports
    uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS_Config
    uCOS-II/Config/: app_cfg.h cpu_cfg.h os_cfg.h
  group USB/STM32_USB_Device_Library/Class/hid
    STM32/Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group USB/STM32_USB_Device_Library/Core
    STM32/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB/STM32_USB_OTG_Driver
    STM32/Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User_Code
    user_code/: main.c
